# Keil uVision project freertos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Coroutines 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Message Buffer 10.3.1, RTOS:Stream Buffer 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.4.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:Startup 2.6.3
